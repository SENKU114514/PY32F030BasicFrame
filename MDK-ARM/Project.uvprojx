# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) IROM2(0x1FFF0E80,0x00000010) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F030x8,USE_FULL_LL_DRIVER,LOG_ENABLE=1
  c include: ..\Inc;..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\BSP\PY32F030xx_Start_Kit;..\EXTERN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x1fff0e80 size 0x10
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f030xx.s
  group Application/User
    ../Src/: main.c py32f0xx_it.c
    ../Inc/: main.h
  group BSP/py32f030xx_Start_Kit
    ../Drivers/BSP/PY32F030xx_Start_Kit/: py32f030xx_ll_Start_Kit.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_spi.c py32f0xx_ll_gpio.c py32f0xx_ll_dma.c py32f0xx_ll_usart.c py32f0xx_ll_tim.c py32f0xx_ll_rtc.c py32f0xx_ll_rcc.c py32f0xx_ll_pwr.c py32f0xx_ll_lptim.c py32f0xx_ll_led.c py32f0xx_ll_i2c.c py32f0xx_ll_exti.c py32f0xx_ll_crc.c py32f0xx_ll_comp.c py32f0xx_ll_adc.c
  group Doc
    ../: readme.txt
  group SYS
    ../EXTERN/SYS/: system_init.c
  group HW_INIT
    ../EXTERN/HW_INIT/GPIO/: GPIO_init.c
    ../EXTERN/HW_INIT/SPI/: SPI_init.c
    ../EXTERN/HW_INIT/TIM/: TIM_init.c
    ../EXTERN/HW_INIT/USART/: USART_init.c
    ../EXTERN/HW_INIT/ADC/: ADC_init.c
    ../EXTERN/HW_INIT/IWDG/: IWDG_init.c
    ../EXTERN/HW_INIT/I2C/: I2C_init.c
    ../EXTERN/HW_INIT/LOWPOWER/: LowPower.c
  group BSP
    ../EXTERN/BSP/UART/: BSP_UART.c
  group SERVER
    ../EXTERN/SERVER/LOG/: LOG.c
    ../EXTERN/SERVER/KEY/: KEY_FSM.c
    ../EXTERN/SERVER/JSON/: JSON_Parse.c
    ../EXTERN/SERVER/QUEUE/: Queue.c
    ../EXTERN/SERVER/IR/: IR_Receive.c
  group RTOS
    ../EXTERN/RTOS/: RTOS.c switch.s
  group MAG
    ../EXTERN/MAG/: mag_task.c mag_tick.c mag_scheduler.c
  group APP
    ../EXTERN/APP/: app_main.c
    ../EXTERN/APP/APP_INPUT/: APP_input.c
    ../EXTERN/APP/APP_OUTPUT/: APP_output.c
    ../EXTERN/APP/APP_COMM/: APP_comm.c
